## TransmitterBuild/Transmitter/Kconfig/boards/Kconfig.nrf52840dk
```kconfig
# Load board Kconfig descriptions.
osource "C:/ncs/v3.0.2/zephyr/boards/nordic/nrf52840dk/Kconfig.nrf52840dk"
```
